#bluetooth is causing issues
PACKAGECONFIG_remove = "bluetooth"
